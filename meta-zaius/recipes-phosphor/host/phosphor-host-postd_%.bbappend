PACKAGECONFIG_zaius_append = " 7seg"
